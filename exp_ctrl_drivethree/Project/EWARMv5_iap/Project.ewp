# IAR project Project.ewp, settings and files
configuration STM3210C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; SERVER; IAP_MODE_SYS
  ICCARM.CCDiagSuppress: Pe236
  ICCARM.CCIncludePath2: ..\inc; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\STM3210C_EVAL; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Utilities\lwip-1.3.1\port\; ..\..\Libraries\STM32_ETH_Driver\inc; ..\..\Libraries\CMSIS\Core\CM3; ..\..\Utilities\lwip-1.3.1\port; ..\..\Utilities\lwip-1.3.1\src\include; ..\..\Utilities\lwip-1.3.1\src\include\ipv4; ..\..\Utilities\lwip-1.3.1\src\include\lwip; ..\..\Utilities\efsl\include; ..\..\Utilities\efsl\include\interface
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: exp_car_ctrl_slaver_v1.4.0.2_20230620.bin
  ILINK.IlinkOutputFile: STM3210C-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group ETHLib
    ../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group EWARMv5
    ../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s
  group FWLib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group LwIP
    ../../Utilities/lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
    ../../Utilities/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Utilities/lwip-1.3.1/src/core/: dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../Utilities/lwip-1.3.1/src/netif/: etharp.c
    ../../Utilities/lwip-1.3.1/port/: ethernetif.c
  group User
    ../src/: can1_bus.c can2_bus.c data.c fun.c list.c main.c netconf.c photo.c position.c stm32f107.c stm32f10x_it.c TCPclient.c uart4.c usart1.c usart2.c
